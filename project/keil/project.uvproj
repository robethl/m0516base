# Keil uVision project project.uvproj, settings and files
target M0516_Baseline (ARM-ADS)
  device: M0516LAN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: M0516_Baseline +hex
  c flags: Optim=4 wLevel=2
  c include: ..\..\lib\Device\Nuvoton\M051Series\Include;..\..\lib\StdDriver\inc;..\..\app\inc\algorithm;..\..\app\inc\gpio;..\..\app\inc\i2c;..\..\app\inc\led;..\..\app\inc\uart;..\..\app\inc\fmc;..\..\app\inc\flash;..\..\app\inc\fpga;..\..\app\inc\spi;..\..\app\inc\tftp;..\..\app\inc\time;..\..\app\inc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M051Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group startup
    ../../lib/Device/Nuvoton/M051Series/Source/ARM/: startup_M051Series.s
  group app
    ../../app/src/: main.c
    ../../app/src/i2c/: app_i2c.c
    ../../app/src/time/: app_time.c
    ../../app/src/uart/: app_uart.c
    ../../app/src/algorithm/: app_algorithm.c
    ../../app/src/led/: app_led.c
    ../../app/src/fmc/: app_fmc.c
    ../../app/src/fpga/: app_fpga.c
    ../../app/src/flash/: app_flash.c
    ../../app/src/spi/: app_spi.c
    ../../app/src/tftp/: app_tftp.c
  group lib
    ../../lib/Device/Nuvoton/M051Series/Source/: system_M051Series.c
    ../../lib/StdDriver/src/: gpio.c i2c.c sys.c spi.c uart.c clk.c retarget.c
